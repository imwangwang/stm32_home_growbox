# Keil uVision project STM32-DEMO.uvproj, settings and files
target ADC-DEMO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\defines;..\tm_stm32fdelay;..\tm_stm32fds18b20;..\tm_stm32fonewire;..\tm_stm32fam2301;..\tm_stm32frtc;..\tm_stm32fusart;..\tm_stm32fgpio;..\tm_stm32fadc;..\tm_stm32ffatfs;..\tm_stm32ffatfs\fatfs;..\tm_stm32ffatfs\fatfs\drivers;..\estw-1.0.1\stw\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: stm32f10x_it.c debug_uart.c ipc.c resources.c realmain.c
    ../tm_stm32fdelay/: tm_stm32f4_timer_properties.c tm_stm32f4_delay.c
    ../tm_stm32fds18b20/: tm_stm32f4_ds18b20.c
    ../tm_stm32fonewire/: tm_stm32f4_onewire.c
    ../tm_stm32fam2301/: tm_stm32f4_am2301.c
    ../tm_stm32frtc/: tm_stm32f4_rtc.c
    ../tm_stm32fgpio/: tm_stm32f4_gpio.c
    ../tm_stm32fusart/: tm_stm32f4_usart.c
    ../tm_stm32fadc/: tm_stm32f4_adc.c
    ../tm_stm32ffatfs/: tm_stm32f4_fatfs.c
    ../tm_stm32ffatfs/fatfs/: diskio.c ff.c
    ../tm_stm32ffatfs/fatfs/option/: syscall.c unicode.c
    ../tm_stm32ffatfs/fatfs/drivers/: fatfs_sd_sdio.c
    ../estw-1.0.1/stw/src/: stw_timer.c stw_system_timer.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c misc.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
